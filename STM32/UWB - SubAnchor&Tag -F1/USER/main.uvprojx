# Keil uVision project main.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE;..\HARDWARE\decadriver;..\HARDWARE\decaplatform;..\HARDWARE\algorithm;..\HARDWARE\solutions
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_exti.c stm32f10x_crc.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: Btn.c Led.c OLED_SPI.c Bmp.c SPI.c DW1000.c timer.c
    ../HARDWARE/decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
    ../HARDWARE/decaplatform/: deca_mutex.c deca_sleep.c deca_spi.c port.c
    ../HARDWARE/algorithm/: trilateration.c kalman.c matrix.c
    ../HARDWARE/solutions/: ss_twr_init.c ss_twr_resp.c ds_twr_init.c ds_twr_resp.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
