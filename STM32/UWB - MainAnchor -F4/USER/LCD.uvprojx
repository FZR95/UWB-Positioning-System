# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\TOUCH;..\HARDWARE\solutions;..\HARDWARE\decadriver;..\HARDWARE\decaplatform;..\HARDWARE\algorithm;..\HARDWARE\KEY;..\HARDWARE\ESP8266;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/: UI.c DW1000.c timer.c
    ../HARDWARE/TOUCH/: bsp_spi_flash.c fonts.c palette.c bsp_xpt2046_lcd.c bsp_ili9341_lcd.c
    ../HARDWARE/decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
    ../HARDWARE/decaplatform/: deca_mutex.c deca_sleep.c deca_spi.c port.c
    ../HARDWARE/solutions/: ds_twr_init.c ds_twr_resp.c ss_twr_init.c ss_twr_resp.c
    ../HARDWARE/algorithm/: kalman.c matrix.c trilateration.c trilateration_basic.c trilateration_EKF.c
    ../HARDWARE/KEY/: Btn.c
    ../HARDWARE/ESP8266/: ADC.c ESP8266.c
    ../SYSTEM/usart/: usart3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_iwdg.c
